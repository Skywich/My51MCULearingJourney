# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h LCD1602.c LCD1602.h Timer0_Init.c Timer0_Init.h Timer1_Init.c Timer1_Init.h BuzzerPlay.c BuzzerPlay.h MARTRIXKEY.c MATRIXKEY.h
